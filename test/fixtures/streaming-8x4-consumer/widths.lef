VERSION 5.8 ;
NONDEFAULTRULE WIDE_Metal1
 LAYER Metal1
 WIDTH .32 ;
 SPACING 0.21 ;
 END Metal1
END WIDE_Metal1
NONDEFAULTRULE WIDE_Metal2
 LAYER Metal2
 WIDTH .40 ;
 SPACING 0.21 ;
 END Metal2
END WIDE_Metal2
END LIBRARY
